<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\WaterStation_v2.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_EndDevice</configuration>
            </member>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_Router</configuration>
            </member>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_Router_CC2592</configuration>
            </member>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_EndDevice_CC2592</configuration>
            </member>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_EndDevice_CC2591</configuration>
            </member>
            <member>
                <project>WaterStation_v2</project>
                <configuration>WaterStation_v2_Router_CC2591</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
